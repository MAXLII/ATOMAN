# Keil uVision project hc32f558.uvprojx, settings and files
target hc32f558 (6240000::V6.24::ARMCLANG)
  device: HC32F558QETJ HDSC
  pack: HDSC.HC32F558.0.0.3-b
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000000,0x1800) IRAM1(0x1FFF8000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: hc32f558 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: HC32F558,PLATFORM_HC32F558,TOOLCHAIN_MDK,USE_DDL_DRIVER
  c include: ..\src;..\bsp;..\inc;..\src;..\..\..\code\section\baremetal;..\..\..\code\section;..\..\..\code\data_source\comm;..\..\..\code\data_source\demo;..\..\..\code\data_pool\demo;..\..\..\code\interface\demo\common;..\..\..\code\interface;..\..\..\code\dbg;..\Firmware\CMSIS\HDSC\hc32f5xx\Include;..\Firmware\CMSIS\Include;..\Firmware\HC32_LL_Driver\inc;..\..\..\code\business\demo;..\..\..\code\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: .\config\linker\HC32F558xE.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f558.s
    ../Firmware/CMSIS/HDSC/hc32f5xx/Source/: system_hc32f558.c
  group source
    ../src/: main.c systick.c
  group interface
    ../../../code/interface/demo/common/: comm_link.c
  group section
    ../../../code/section/baremetal/: section.c
  group comm
    ../../../code/data_source/comm/: comm.c
  group dbg
    ../../../code/dbg/: shell.c shell_core.c perf.c perf_core.c perf_service.c scope.c scope_core.c scope_service.c shell_service.c trace.c trace_core.c trace_service.c sfra.c sfra_core.c sfra_service.c
  group bsp
    ../bsp/: bsp_clk.c bsp_usart.c bsp_timer.c bsp_gpio.c bsp_adc.c bsp_pwm.c
  group driver
    ../Firmware/HC32_LL_Driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_cordic.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dbgc.c hc32_ll_dma.c hc32_ll_dsogi_pll.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_ermu.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_fmac.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_hrpwm.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_mcan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pid.c hc32_ll_pla.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_sdfm.c hc32_ll_ske.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr6.c hc32_ll_trlpwm.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_vref.c hc32_ll_wdt.c hc32_ll_xbar.c
  group Readme
    ../: Readme.txt
  group app
    ../../../code/business/demo/: demo.c demo_interrupt.c demo_perf.c demo_scope.c demo_sfra.c demo_shell.c demo_task.c demo_trace.c
    ../../../code/data_source/demo/: demo_comm.c
    ../../../code/data_pool/demo/: demo_data_pool.c
  group lib
    ../../../code/lib/: record_dict.c pi_tustin.c dft.c
