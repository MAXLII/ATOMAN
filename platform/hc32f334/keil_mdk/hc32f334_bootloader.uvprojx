# Keil uVision project hc32f334_bootloader.uvprojx, settings and files
target hc32f334_bootloader (6240000::V6.24::ARMCLANG)
  device: HC32F334KATI HDSC
  pack: HDSC.HC32F334.1.0.0
  cpu: IROM1(0x00000000,0x4000) IROM2(0x03000000,0x1800) IRAM1(0x1FFFC000,0x8000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: hc32f334_bootloader +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: HC32F334,PLATFORM_HC32F334,TOOLCHAIN_MDK,USE_DDL_DRIVER,FIRMWARE_TYPE_BOOTLOADER,BOOTLOADER_PROTOCOL_FRAME_SERVICE_ENABLE,HC32F334_IAP_BASE=0x00004000UL
  c include: ..\bootloader;..\bsp;..\inc;..\src;..\Firmware\CMSIS\Include;..\Firmware\CMSIS\HDSC\hc32f3xx\Include;..\Firmware\HC32_LL_Driver\inc;..\..\..\code\section\baremetal;..\..\..\code\section;..\..\..\code\data_source\comm;..\..\..\code\data_source\demo;..\..\..\code\dbg;..\..\..\code\lib\fal;..\..\..\code\app\bootloader\core;..\..\..\code\app\bootloader\protocol;..\..\..\code\app\bootloader\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F334_bootloader.sct
  link misc: --keep=*Handler
  group bootloader
    ../bootloader/: main.c bootloader_fal_adapter.c boot_uart.c boot_comm_link.c hc32_boot_platform.c fal_cfg.c
  group platform
    ../bsp/: bsp_clk.c bsp_efm_flash.c bsp_w25q64.c
    ../src/: systick.c
    ../bootloader/: boot_interrupt.c
  group core
    ../../../code/section/baremetal/: section.c
    ../../../code/data_source/comm/: comm.c
    ../../../code/lib/fal/: fal_core.c
    ../../../code/app/bootloader/core/: bootloader_core.c bootloader_metadata.c
    ../../../code/app/bootloader/protocol/: bootloader_protocol.c
  group startup
    ./: startup_hc32f334.s
  group vendor
    ../Firmware/CMSIS/HDSC/hc32f3xx/Source/: system_hc32f334.c
    ../Firmware/HC32_LL_Driver/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_spi.c hc32_ll_usart.c hc32_ll_utility.c
