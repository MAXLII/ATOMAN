# Keil uVision project hc32f334_ac.uvprojx, settings and files
target ISP (6240000::V6.24::ARMCLANG)
  device: HC32F334KATI HDSC
  pack: HDSC.HC32F334.1.0.0
  cpu: IROM1(0x00000000,0x20000) IROM2(0x03000000,0x1800) IRAM1(0x1FFFC000,0x8000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: hc32f334_ac_isp +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HC32F334,PLATFORM_HC32F334,TOOLCHAIN_MDK,USE_DDL_DRIVER,FIRMWARE_TYPE_ISP,IS_AC,CTRL_PWM_TIMER_FREQ_HZ=120000000UL
  c include: ..\src;..\bsp;..\inc;..\src;..\Firmware\CMSIS\Include;..\Firmware\CMSIS\HDSC\hc32f3xx\Include;..\Firmware\HC32_LL_Driver\inc;..\..\..\code\section\srtos_m;..\..\..\code\section;..\..\..\code\data_source\comm;..\..\..\code\data_source\demo;..\..\..\code\data_pool\demo;..\..\..\code\interface\demo\common;..\..\..\code\lib;..\..\..\code\dbg;..\..\..\code\business\demo;..\..\..\code\app\bootloader\iap;..\..\..\code\app\bootloader\protocol;..\..\..\code\app\bootloader\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F334_isp.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f334.s
    ../Firmware/CMSIS/HDSC/hc32f3xx/Source/: system_hc32f334.c
  group source
    ../src/: main.c
  group app
    ../../../code/business/demo/: demo.c demo_interrupt.c demo_perf.c demo_scope.c demo_sfra.c demo_shell.c demo_task.c demo_trace.c
    ../../../code/data_source/demo/: demo_comm.c
    ../../../code/data_pool/demo/: demo_data_pool.c
  group bsp
    ../bsp/: bsp_clk.c bsp_gpio.c bsp_pwm.c bsp_usart.c bsp_can.c bsp_timer.c
  group interface
    ../../../code/interface/demo/common/: gpio.c comm_link.c
  group section
    ../../../code/section/srtos_m/: section.c
  group comm
    ../../../code/data_source/comm/: comm.c
  group lib
    ../../../code/lib/: record_dict.c pi_tustin.c dft.c
  group runtime
    ../src/: hc32f334_it.c syscalls.c systick.c
    ../../../code/app/bootloader/iap/: iap_update_service.c
  group driver
    ../Firmware/HC32_LL_Driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dbgc.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hrpwm.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_mcan.c hc32_ll_mpu.c hc32_ll_pla.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c
  group dbg
    ../../../code/dbg/: perf.c perf_core.c perf_service.c section_list_service.c scope.c scope_core.c scope_service.c shell.c shell_core.c shell_service.c sfra.c sfra_core.c sfra_service.c trace.c trace_core.c trace_service.c
target IAP (6240000::V6.24::ARMCLANG)
  device: HC32F334KATI HDSC
  pack: HDSC.HC32F334.1.0.0
  cpu: IROM1(0x00004000,0x1C000) IROM2(0x03000000,0x1800) IRAM1(0x1FFFC000,0x8000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: hc32f334_ac_iap +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HC32F334,PLATFORM_HC32F334,TOOLCHAIN_MDK,USE_DDL_DRIVER,IS_IAP,IS_AC,CTRL_PWM_TIMER_FREQ_HZ=120000000UL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F334xA.sct
  link misc: --keep=*Handler
