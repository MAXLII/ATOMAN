# Keil uVision project gd32g553.uvprojx, settings and files
target gd32g553 (6240000::V6.24::ARMCLANG)
  device: GD32G553RE GigaDevice
  pack: GigaDevice.GD32G5x3_DFP.1.3.0
  cpu: IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: isp_firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32G5X3,PLATFORM_GD32G553C,TOOLCHAIN_MDK,FIRMWARE_TYPE_ISP,APP_START_ADDR=0x08000000
  c include: ..\..\..\code\business\demo;..\..\..\code\data_source\demo;..\..\..\code\data_pool\demo;..\..\..\code\lib;..\..\..\code\dbg;..\..\..\code\interface\demo\common;..\..\..\code\interface;..\..\..\code\section\srtos_m;..\..\..\code\section;..\..\..\code\data_source\comm;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32G5x3\Include;..\Firmware\GD32G5x3_standard_peripheral\Include;..\inc;..\bsp\inc
  asm define: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\gd32g553.sct
  group Startup
    ./: startup_gd32g5x3.s
  group src
    ../src/: gd32g5x3_it.c main.c systick.c
  group driver
    ../Firmware/GD32G5x3_standard_peripheral/Source/: gd32g5x3_adc.c gd32g5x3_can.c gd32g5x3_cau_aes.c gd32g5x3_cau_des.c gd32g5x3_cau_tdes.c gd32g5x3_cau.c gd32g5x3_cla.c gd32g5x3_cmp.c gd32g5x3_cpdm.c gd32g5x3_crc.c gd32g5x3_dac.c gd32g5x3_dbg.c gd32g5x3_dma.c gd32g5x3_exmc.c gd32g5x3_exti.c gd32g5x3_fac.c gd32g5x3_fft.c gd32g5x3_fmc_ramfunc.c gd32g5x3_fmc.c gd32g5x3_fwdgt.c gd32g5x3_gpio.c gd32g5x3_hpdf.c gd32g5x3_hrtimer.c gd32g5x3_i2c.c gd32g5x3_lptimer.c gd32g5x3_misc.c gd32g5x3_pmu.c gd32g5x3_qspi.c gd32g5x3_rcu.c gd32g5x3_rtc.c gd32g5x3_spi.c gd32g5x3_syscfg.c gd32g5x3_timer.c gd32g5x3_tmu.c gd32g5x3_trigsel.c gd32g5x3_trng.c gd32g5x3_usart.c gd32g5x3_vref.c gd32g5x3_wwdgt.c
  group cmsis
    ../Firmware/CMSIS/GD/GD32G5x3/Source/: system_gd32g5x3.c
  group bsp
    ../bsp/src/: bsp_can.c bsp_gpio.c bsp_init.c bsp_timer.c bsp_usart.c
  group app
    ../../../code/business/demo/: demo.c demo_interrupt.c demo_jitter.c demo_rtos_risk.c demo_perf.c demo_scope.c demo_sfra.c demo_shell.c demo_task.c demo_trace.c
    ../../../code/data_source/demo/: demo_comm.c
    ../../../code/data_pool/demo/: demo_data_pool.c
  group lib
    ../../../code/lib/: dft.c pi_tustin.c pr.c record_dict.c sogi.c
  group dbg
    ../../../code/dbg/: perf.c perf_core.c perf_service.c scope.c scope_core.c scope_service.c sfra.c sfra_core.c sfra_service.c trace.c trace_core.c trace_service.c shell.c shell_core.c shell_service.c
  group interface
    ../../../code/interface/demo/common/: gpio.c comm_link.c jitter.c
  group section
    ../../../code/section/srtos_m/: section.c
  group comm
    ../../../code/data_source/comm/: comm.c
