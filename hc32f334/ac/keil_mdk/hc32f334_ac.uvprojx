# Keil uVision project hc32f334_ac.uvprojx, settings and files
target hc32f334_ac (6240000::V6.24::ARMCLANG)
  device: HC32F334KATI HDSC
  pack: HDSC.HC32F334.1.0.0
  cpu: IROM1(0x00000000,0x20000) IROM2(0x03000000,0x1800) IRAM1(0x1FFFC000,0x8000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: hc32f334_ac +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HC32F334,USE_DDL_DRIVER,IS_HC32,FIRMWARE_TYPE_ISP,APP_START_ADDR=0x00000000,VECT_TAB_OFFSET=0x00000000,TOOLCHAIN_KEIL,IS_AC
  c include: ..\ac\src;..\ac\bsp;..\inc;..\src;..\Firmware\CMSIS\Include;..\Firmware\CMSIS\HDSC\hc32f3xx\Include;..\Firmware\HC32_LL_Driver\inc;..\..\code\section;..\..\code\comm;..\..\code\interface\ac;..\..\code\interface\common;..\..\code\lib;..\..\code\dbg;..\..\code\app\demo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F334xA.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f334.s
    ../Firmware/CMSIS/HDSC/hc32f3xx/Source/: system_hc32f334.c
  group source
    ../ac/src/: main.c
  group app
    ../../code/app/demo/: demo.c
  group bsp
    ../ac/bsp/: bsp_clk.c bsp_gpio.c bsp_pwm.c bsp_usart.c bsp_can.c bsp_timer.c
  group interface
    ../../code/interface/ac/: gpio.c pwm.c comm_link.c
  group section
    ../../code/section/: section.c
  group comm
    ../../code/comm/: comm.c
  group lib
    ../../code/lib/: record_dict.c
  group runtime
    ../src/: hc32f334_it.c syscalls.c systick.c
  group driver
    ../Firmware/HC32_LL_Driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dbgc.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hrpwm.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_mcan.c hc32_ll_mpu.c hc32_ll_pla.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c
  group dbg
    ../../code/dbg/: perf.c perf_service.c scope.c scope_service.c shell.c shell_service.c trace.c trace_service.c
